# Keil uVision project CS75CommonFirmware.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CS75CommonFirmware
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CORE_BOARD_A HSE_VALUE=20000000 LCD_USE_STM32F429_EVAL
  c include: ..\..\src;..\..\inc;..\..\config; ..\..\lib\TM_Drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
    ../../src/: common.c can.c i2c.c imu.c motors.c
    ../../src/boards/: core.c
  group TMLibs
    ../../lib/TM_Drivers/: tm_stm32_dma2d_graphic.c tm_stm32_fonts.c tm_stm32_gpio.c tm_stm32_spi.c tm_stm32_sdram.c tm_stm32_lcd.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.4.2, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:CAN 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:DMA2D 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:I2C 1.4.2, Device:STM32Cube HAL:LTDC 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:SDRAM 1.4.2, Device:STM32Cube HAL:SPI 1.4.2, Device:Startup 2.4.2
