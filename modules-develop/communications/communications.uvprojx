# Keil uVision project communications.uvprojx, settings and files
target Test Filtering (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: communications
  BeforeMake: ruby ..\Unity\auto\generate_test_runner.rb tests\test_filtering.c test_runners\test_filtering_runner.c
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: UNITY_INCLUDE_DOUBLE
  c include: ..\Unity\src;.\src;.\tests
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: main.c message_callbacks_nofilter.c
  group filtering_src
    ./src/: retarget.c filtering.c
  group firmware
    ../commonsw/firmware/src/: can.c common.c retarget.c rtc.c uart.c
    ../commonsw/firmware/src/boards/: comm.c
  group commonsw
    ../commonsw/src/: heartbeat.c messaging.c fault.c
  group tests
    ./tests/: test_filtering.c
  group Unity
    ../Unity/src/: unity.c
  group test runners
    ./test_runners/: test_filtering_runner.c
target Physical Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: communications
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: COMM_BOARD_C HSE_VALUE=8000000 DEBUG
  c include: .\src;..\commonsw\inc;..\commonsw\firmware\inc;..\commonsw\firmware\config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Physical Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: communications
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: COMM_BOARD_C HSE_VALUE=8000000
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.4.2, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:CAN 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:RTC 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:Startup 2.4.2
