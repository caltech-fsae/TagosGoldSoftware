# Keil uVision project temp_monitoring.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TemperatureTest
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: IO_BOARD_C, HSE_VALUE=8000000
  c include: ..\..\..\commonsw\firmware\config;..\..\..\commonsw\firmware\inc;..\..\..\commonsw\firmware\src;..\..\src;..\..\..\commonsw\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ../../src/: temp_monitoring.c
    ../../../commonsw/firmware/src/: temperature.c common.c i2c.c can.c adc.c
    ./: main.c
    ../../../commonsw/src/: messaging.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:STM32Cube Framework:Classic 1.4.2, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:CAN 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:I2C 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:Startup 2.4.2
