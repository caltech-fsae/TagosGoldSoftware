# Keil uVision project shutdown.uvprojx, settings and files
target Physical Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: shutdown
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: SHUTDOWN_BOARD_C HSE_VALUE=8000000
  c include: ..\commonsw\firmware\config;..\commonsw\firmware\inc;..\commonsw\firmware\src;..\commonsw\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: main.c shutdown.c relays.c bms_monitoring.c
  group firmware
    ../commonsw/firmware/src/: bms.c can.c common.c i2c.c retarget.c temperature.c uart.c adc.c rtc.c
    ../commonsw/firmware/src/boards/: shutdown.c
  group commonsw
    ../commonsw/src/: heartbeat.c messaging.c fault.c
target Physical Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: shutdown
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: SHUTDOWN_BOARD_C HSE_VALUE=8000000 DEBUG
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:STM32Cube Framework:Classic 1.4.2, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:CAN 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:I2C 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:RTC 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:Startup 2.4.2
