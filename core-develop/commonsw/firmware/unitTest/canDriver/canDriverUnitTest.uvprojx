# Keil uVision project canDriverUnitTest.uvprojx, settings and files
target Target Core Rev A (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: canDriverUnitTest
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_BOARD_A HSE_VALUE=20000000
  c include: ..\..\inc;..\..\src;..\..\config
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
    ../../src/: can.c common.c
    ../../config/: config_core_c.h
target Target Core Rev C (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: canDriverUnitTest
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_BOARD_C HSE_VALUE=8000000
  c include: ..\..\inc;..\..\src;..\..\config
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Target IO Rev B (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: canDriverUnitTest
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: IO_BOARD_B HSE_VALUE=8000000
  c include: ..\..\inc;..\..\src;..\..\config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Target IO Rev C (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: canDriverUnitTest
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: IO_BOARD_C HSE_VALUE=8000000 FIRMWARE_ONLY
  c include: ..\..\inc;..\..\src;..\..\config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Target Comm Rev B (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: canDriverUnitTest
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: COMM_BOARD_B HSE_VALUE=8000000
  c include: ..\..\inc;..\..\src;..\..\config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Target Shutdown Rev C (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: canDriverUnitTest
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: SHUTDOWN_BOARD_C HSE_VALUE=8000000
  c include: ..\..\inc;..\..\src;..\..\config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:STM32Cube Framework:Classic 1.4.2, Device:STM32Cube HAL:CAN 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:I2C 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:Startup 2.4.2
